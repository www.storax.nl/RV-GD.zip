Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: b7790e22-0d4e-43f9-92e0-be49955fca9f.ifc
Time: 2026-08-11T15:20:54
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - RV-GD 86, 600x800mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAI7ddhcFAAAA5eoCAAV2SgAA2FMBAInDAACd7AIAtewCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAI7ddhcFAAAA5eoCAAV2SgAA2FMBAInDAACd7AIAtewCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 939 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 905 mm; gewicht per st: 41 kg/st; serie: RV-GD; afsluitbaar: True; hoogte: 182 mm; merk: Storax; breuklast: A15; type: 86; dagmaatbreedte: 800 mm; omranding: staal; luik: staal; aandrijving: Storax - gasdrukveer
